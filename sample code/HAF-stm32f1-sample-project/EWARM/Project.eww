<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\HAF2x_stm32f1_demo.ewp</path>
  </project>
  <batchBuild />
</workspace>
